require linux-ublox.inc

LINUX_VERSION = "3.19"

SRCREV = "93a33443286ffc58a4bec7d796012724e22238ec"
