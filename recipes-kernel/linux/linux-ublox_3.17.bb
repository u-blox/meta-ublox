require linux-ublox.inc

LINUX_VERSION = "3.17"

SRCREV = "e1b3371a5e832cc61e9833233090b059e96343df"
